<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32F407_Uniqe_ID_Read.ewp</path>
  </project>
  <batchBuild />
</workspace>
